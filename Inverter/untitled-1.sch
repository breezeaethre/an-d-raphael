v {xschem version=3.4.6RC file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {/home/raphael03/untitled.sym} -10 -10 0 0 {name=x1}
